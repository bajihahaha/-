# Keil uVision project FM33A0XXEV_Tester.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33A06XEV FMSH
  pack: Keil.FM33A0XXEV_DFP.0.0.4
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33A0XXEV_Tester +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __VTOR_PRESENT
  c include: ..\UserCode;..\Drivers;..\rt-thread\include;..\rt-thread\libcpu\arm\common;..\rt-thread\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group UserCode
    ../UserCode/: main.c user_init.c uart.c lptimer32.c sleep.c adc.c spi.c flash.c rtc.c lptim.c EC800.c bt16.c
    ../rt-thread/bsp/: board.c
  group stdperiph_driver
    ../Drivers/: fm33a0xxev_adc.c fm33a0xxev_aes.c fm33a0xxev_bstim.c fm33a0xxev_bt.c fm33a0xxev_cdif.c fm33a0xxev_cmu.c fm33a0xxev_comp.c fm33a0xxev_crc.c fm33a0xxev_dbg.c fm33a0xxev_dma.c fm33a0xxev_et.c fm33a0xxev_flash.c fm33a0xxev_gpio.c fm33a0xxev_hash.c fm33a0xxev_i2c.c fm33a0xxev_iwdt.c fm33a0xxev_lpuart.c fm33a0xxev_lcd.c fm33a0xxev_lptim.c fm33a0xxev_pae.c fm33a0xxev_pmu.c fm33a0xxev_qspi.c fm33a0xxev_rmu.c fm33a0xxev_rng.c fm33a0xxev_spi.c fm33a0xxev_svd.c fm33a0xxev_u7816.c fm33a0xxev_uart.c fm33a0xxev_vrtc.c fm33a0xxev_wwdt.c fm33a0xxev_rtc.c
  group Kernel
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group CPU
    ../rt-thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
