# IAR project FM33A0XXEV.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: FM33A06XEV FMSH FM33A06XEV
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\Drivers; Device\IncludeIAR; ..\UserCode; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\rt-thread\include; ..\rt-thread\libcpu\arm\common; ..\rt-thread\bsp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\rt-thread\libcpu\arm\cortex-m0
  OBJCOPY.OOCOutputFile: FM33A0XXEV.hex
  ILINK.IlinkOutputFile: FM33A0XXEV.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\FMSH\FM33A06XEV.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Debug/CPU
    ../rt-thread/libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group Debug/Device
    Device/Source/IAR/: startup_FM33A0XXEV.s
    Device/Source/: system_FM33A0XXEV.c
  group Debug/Kernel
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Debug/stdperiph_driver
    ../Drivers/: fm33a0xxev_adc.c fm33a0xxev_adc.h fm33a0xxev_aes.c fm33a0xxev_aes.h fm33a0xxev_bstim.c fm33a0xxev_bstim.h fm33a0xxev_bt.c fm33a0xxev_bt.h fm33a0xxev_cdif.c fm33a0xxev_cdif.h fm33a0xxev_cmu.c fm33a0xxev_cmu.h fm33a0xxev_comp.c fm33a0xxev_comp.h fm33a0xxev_crc.c fm33a0xxev_crc.h fm33a0xxev_dbg.c fm33a0xxev_dbg.h fm33a0xxev_dma.c fm33a0xxev_dma.h fm33a0xxev_et.c fm33a0xxev_et.h fm33a0xxev_flash.c fm33a0xxev_flash.h fm33a0xxev_gpio.c fm33a0xxev_gpio.h fm33a0xxev_hash.c fm33a0xxev_hash.h fm33a0xxev_i2c.c fm33a0xxev_i2c.h fm33a0xxev_iwdt.c fm33a0xxev_iwdt.h fm33a0xxev_lcd.c fm33a0xxev_lcd.h fm33a0xxev_lptim.c fm33a0xxev_lptim.h fm33a0xxev_lpuart.c fm33a0xxev_lpuart.h fm33a0xxev_pae.c fm33a0xxev_pae.h fm33a0xxev_pmu.c fm33a0xxev_pmu.h fm33a0xxev_qspi.c fm33a0xxev_qspi.h fm33a0xxev_rmu.c fm33a0xxev_rmu.h fm33a0xxev_rng.c fm33a0xxev_rng.h fm33a0xxev_rtc.c fm33a0xxev_rtc.h fm33a0xxev_spi.c fm33a0xxev_spi.h fm33a0xxev_svd.c fm33a0xxev_svd.h fm33a0xxev_u7816.c fm33a0xxev_u7816.h fm33a0xxev_uart.c fm33a0xxev_uart.h fm33a0xxev_vrtc.c fm33a0xxev_vrtc.h fm33a0xxev_wwdt.c fm33a0xxev_wwdt.h
  group Debug/UserCode
    ../rt-thread/bsp/: board.c
    ../UserCode/: lptimer32.c main.c sleep.c uart.c user_init.c
